Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2020-04-30T16:35:02
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190510_1515(x64) - Exporter 18.4.0.0 - Alternate UI 18.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Thu Apr 30 16:35:02 2020* Host: NCL-PI19* Database: C:\Users\MatukiNE\AppData\Local\Temp\{E698603B-2800-4137-8C12-E74490B551CC}\ifc* Database version: 5507* Database creation date: Thu Apr 30 16:35:02 2020* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Thu Apr 30 16:35:02 2020* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Thu Apr 30 16:35:02 2020* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: WelfordDomeFreeStandingCanopy, NBS_AbleCanopiesLtd_OpenSddShltrs_WelfordDomeFreeStandingCanopy:WelfordDomeFreeStandingCanopy:191868
In: Level 1
Type - PredefinedType: USERDEFINED; Classification: Pr_20_65_78_58 (Uniclass2015); Material: NBS_Plastic_Clear, NBS_Concept
Type - BOS_General - Author: NBS; BIMObjectName: NBS_AbleCanopiesLtd_OpenSddShltrs_WelfordDomeFreeStandingCanopy; ManufacturerName: Able Canopies Ltd; ManufacturerURL: www.ablecanopies.co.uk; NBSCertification: www.nationalbimlibrary.com/cert/0d5uexvv; NBSDescription: Open sided shelters; NBSReference: 45-05-75/315; ProductInformation: www.ablecanopies.co.uk/canopies/free-standing-canopies/welford-dome-free-standing-canopy.html; Revision: n/a; Uniclass2015Title: Open sided shelters; Uniclass2015Code: Pr_20_65_78_58; Uniclass2015Version: Products v1.17; Version: 1
Type - NBS_Data - FrameMaterial: Steel box section; FrameFinish: Galvanised and powder coated; FrameColour: RAL standard colours (other RAL non-standard colours on request); RoofCovering: Choice of 5mm solid or 16mm structured polycarbonate roof panels; OpeningsDoors: n/a; OpeningsWindows: n/a; OpeningsRoofVents: n/a; IntegralServices: n/a; RainwaterDrainage: Deep flow guttering fitted as standard and included in the price to direct rainwater safely from your canopy; Accessories: Secure roller shutters, Posts pads, Side and front fills, Safety barriers, Signage; ProjectionWidth: 6 m; WallPlates: n/a; RoofSystem: Able Canopies alunimium barrel glaze system; PostsSize: n/a; PostsMaterial: n/a; WeatherResistance: UV absorber added forming a barrier against UV radiation; FirePerformance: Roof sheets remain stabel at very high temperatures
Type - Pset_FurnitureTypeCommon - NominalDepth: 0 mm; NominalHeight: 0 mm; NominalLength: 0 mm; Description: Free standing canopy; MainColor: n/a; Style: Canopy
Type - IFC - IfcExportAs: IfcBuildingElementProxyType; IfcExportType: USERDEFINED
Type - COBie - NominalWidth: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Generic Models; CodePerformance: n/a; Color: n/a; Constituents: n/a; DurationUnit: year; ExpectedLife: 25 years; Features: n/a; Finish: n/a; Grade: n/a; Manufacturer: sales@ablecanopies.co.uk; Material: n/a; ModelNumber: n/a; ModelReference: Welford Dome Free Standing Canopy; Name: OpenSidedShelters_WelfordDomeFreeStandingCanopy_AbleCanopiesLtd; ReplacementCost: n/a; Shape: n/a; Size: n/a; SustainabilityPerformance: n/a; WarrantyDescription: 10 years; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
